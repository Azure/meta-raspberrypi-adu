require adu-delta-test-package.bb

# Version 1.0 of the delta test package recipe
